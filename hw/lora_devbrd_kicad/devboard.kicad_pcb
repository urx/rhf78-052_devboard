# Repository urx/rhf78-052_devboard

## KiCad design hw/lora_devbrd_kicad/devboard.kicad_pcb

Parts:
C1, C4, C6: 100nF; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
C2, C3: 10uF; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
C5: 4.7uF; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
D1: KP-2012SGC; D_0805_2012Metric
D2: KP-2012SYC; D_0805_2012Metric
D3, D4, D5, D6, D7: KP-2012EC; D_0805_2012Metric
J1, J2: Conn_01x11_Male; PinHeader_1x11_P2.54mm_Vertical
J3: 3.3V; PinHeader_1x04_P2.54mm_Vertical
J4: USB_B_Micro; USB_Micro-B_Molex_47346-0001
J5: GND; PinHeader_1x04_P2.54mm_Vertical
J6: LEDS; PinHeader_1x04_P2.54mm_Vertical
J7: SWD; PinHeader_1x05_P2.54mm_Vertical
J8: Conn_01x02_Male; PinHeader_1x02_P2.54mm_Vertical
J9, J10: Conn_Coaxial_Power; SMA_Amphenol_132203-12_Horizontal
R1: 1K; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
R2, R3, R4, R5, R6, R7, R8: 100; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
R9, R10: 440; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder
SW1: FSM8JSMATR; SW_SPST_EVQPE1
U1: rhf78-052; RHF78-052_LCC
U2: LM1117-3.3; SOT-223-3_TabPin2_new-TI
U3: FT232RL; SSOP-28_5.3x10.2mm_P0.65mm

Connections:
+3V3: C1.1, C3.1, C5.1, C6.1, J3.1, J3.2, J3.3, J3.4, J7.5, R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, R7.1, R8.1, U1.1 (VCC), U2.2 (VO), U3.4 (VCCIO), U3.20 (VCC)
+5V: C2.1, J4.1 (VBUS), U2.3 (VI)
ANT_HF: J10.1, U1.30 (RFIO_HF)
ANT_LF: J9.1, U1.32 (RFIO_LF)
CTS: J1.8, U1.10 (CTS)
D+: J4.3 (D+), U3.15 (USBD+)
D-: J4.2 (D-), U3.16 (USBD-)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, D3.1 (K), J4.5 (GND), J4.6 (Shield), J5.1, J5.2, J5.3, J5.4, J7.1, J9.2, J10.2, SW1.1, U1.2 (GND), U1.29 (GND), U1.31 (GND), U1.33 (GND), U2.1 (GND), U3.7 (GND), U3.18 (GND), U3.21 (GND), U3.25 (AGND), U3.26 (TEST)
MISO: J1.6, U1.8 (MISO)
MOSI: J1.7, U1.9 (MOSI)
NSS: J1.4, U1.6 (NSS)
unnamed: C4.1, U3.17 (3V3OUT)
unnamed: D1.2 (A), R2.2
unnamed: D2.2 (A), R3.2
unnamed: D3.2 (A), R4.2
unnamed: D4.1 (K), J6.1
unnamed: D4.2 (A), R5.2
unnamed: D5.1 (K), J6.2
unnamed: D5.2 (A), R6.2
unnamed: D6.1 (K), J6.3
unnamed: D6.2 (A), R7.2
unnamed: D7.1 (K), J6.4
unnamed: D7.2 (A), R8.2
unnamed: J1.10, R9.2
unnamed: J1.11, R10.2
unnamed: J8.1, U3.5 (RXD)
unnamed: J8.2, U3.1 (TXD)
PA0: J2.1, U1.28 (PA0)
PA3: J2.8, U1.20 (PA3)
PA8: J1.1, U1.3 (PA8)
PA9: J1.2, U1.4 (PA9)
PA10: J1.3, U1.5 (PA10)
PA15: J2.11, U1.14 (PA15)
PB3: J2.10, U1.15 (PB3)
PB4: J2.9, U1.16 (PB4)
PB5: J2.7, U1.21 (PB5)
PC13: J2.2, U1.26 (PC13)
RTS: J1.9, U1.11 (RTS)
RX: J2.5, U1.23 (RX)
RX_LED: D2.1 (K), U3.22 (CBUS1)
SCK: J1.5, U1.7 (SCK)
SCL: J2.4, U1.24 (SCL)
SDA: J2.3, U1.25 (SDA)
SWCLK: J7.2, R10.1, U1.13 (SWCLK)
SWDIO: J7.3, R9.1, U1.12 (SWDIO)
TX: J2.6, U1.22 (TX)
TX_LED: D1.1 (K), U3.23 (CBUS0)
nRST: J7.4, R1.2, SW1.2, U1.27 (nRST)

Board: 2 copper layers, 64.1 x 58.9 mm, 37 parts (19 on the bottom side), 48 nets.

## Commit log

2019-09-16 RHF78-052 docs
2019-10-21 Initial devboard commit.
    TODO:
    * add 5V -> 3.3V LDO
    * route micro-usb connector
    * add 5V led
    * add 3.3V led
    * add led with pin header for connect to any gpio by wire
2019-10-23 Adds FT232RL
    TODO:
    * add LM1117/SOT-23
    * trace board
    * check, check, check
2019-10-23 Adds LM1117
    TODO:
    * trace board
    * check, check, check
2019-10-23 Adds some leds for power, rx/tx and custom indication
    TODO:
    * trace board
    * check footprints
    * check, check, check
2019-10-23 WIP: tracing
2019-10-28 Switch to github eagle libraries
2019-10-29 WIP: RHF78-052 component
2019-10-29 WIP: RHF78-052 development board
2019-10-29 WIP: [kicad] adds peripherail connectors in schematics
2019-10-29 WIP: [kicad] adds some network names to RHF78-052 pins
2019-10-29 WIP: [kicad] adds ft232rl and some indication led (pwr,rx,tx)
2019-10-30 WIP: [kicad] adds usb connector, lm1117, custom indication leds, pwr and gnd connectors
2019-10-30 WIP: [kicad] ERC OK
2019-10-30 WIP: [kicad] adds yellow and green leds for TX/RX indication
2019-10-30 WIP: [kicad] adds rhf78-052-lcc footprint
2019-11-01 FEAT: [kicad] finished footprint of RHF78-052_LCC
2019-11-04 WIP: added new footprints, sch updated, pcb updated, components placed
2019-11-04 MISC: adds gitignore file
2019-11-05 MISC: [kicad] adds reset button and resistor on SWDIO and SWCLK lines
2019-11-05 MISC: [kicad] sets top layer componetns to it's places
2019-11-05 WIP: [kicad] changed footprints for R and C to 1206
2019-11-06 WIP: [kicad] Components and designators are placed finally
2019-11-06 SX1278 datasheet
2019-11-06 WIP: [kicad] Routed; antennas will be added yet
2019-11-06 MISC: [kicad] updates gitignore file
2019-11-07 WIP: [kicad] adds antennas, routing
2019-11-07 WIP: [kicad] Routing, adds polygons and vias
2019-11-08 FEAT: [kicad] DIY PCB is ready
2019-11-08 FEAT: [kicad] PCB is ready
2019-11-08 FEAT: [kicad] removes misplaced via, removes some unneeded gnd routes
2019-11-08 MISC: [kicad] add some nice writings ^_^
2019-11-09 FEAT: switch to KiCAD
2019-12-06 MISC: added a BOM ordered with ChipDip
2019-12-08 FEAT: adds openocd config
2020-01-01 simple blinker app
